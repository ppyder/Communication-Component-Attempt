# Keil uVision project ClassDemo.uvprojx, settings and files
target ClassDemo (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F429IGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.9.0
  cpu: IRAM(0x20000000-0x2002FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: ClassDemo +hex
  c flags: Optim=4 OneElfS=1 uC99=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F429xx
  c include: ../Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;..\HEROLib\Dev_Interface\Comunication;..\HEROLib\Universal;..\HEROLib\Universal\Controller;..\HEROLib\Universal\Filter;..\HEROLib\Universal\SignalGenerator;..\HEROLib\Universal\Simu_Half_Duplex;..\HEROLib\Devices\M3508;..\HEROLib\Devices\Master_Communication;..\HEROLib\Devices\PC_Communication;..\HEROLib\Devices\BSP_Communication;..\HEROLib\DebugSupport\TestController;..\Middlewares;..\Middlewares\CAN_Devices;..\Applications
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f429xx.s
  group Application/User
    ../Src/: main.c gpio.c can.c dma.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_can.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c
  group Drivers/CMSIS
    ..//Src/: system_stm32f4xx.c
  group HEROLib/Universal
    ../HEROLib/Universal/Simu_Half_Duplex/: Half_Duplex.c
    ../HEROLib/Universal/Controller/: Controller.c
    ../HEROLib/Universal/Filter/: filter.c
    ../HEROLib/Universal/SignalGenerator/: SignalGenerator.c
  group HEROLib/Dev_Interface
    ../HEROLib/Dev_Interface/Comunication/: Comunication.c Com_CanDriver.c Com_UserModules.c
  group HEROLib/Devices
    ../HEROLib/Devices/PC_Communication/: ComToPC.c
    ../HEROLib/Devices/BSP_Communication/: ComToBSP.c
    ../HEROLib/Devices/Master_Communication/: ComToMaster.c MasterDataDeal.c
    ../Middlewares/CAN_Devices/: ComToCAN_Dev.c
    ../HEROLib/Devices/M3508/: M3508.c
  group HEROLib/DebugSupport
    ../HEROLib/DebugSupport/TestController/: TestCtrl.c
  group Middlewares/Devices
    ../Middlewares/: middleInit.c
software components: CMSIS:CORE 4.3.0
